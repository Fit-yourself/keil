# Keil uVision project adc14_single_conversion_repeat_timera_source.uvprojx, settings and files
target adc14_single_conversion_repeat_timera_source (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc14_single_conversion_repeat_timera_source
  AfterMake: fromelf --bin --output .\Build\adc14_single_conversion_repeat_timera_source.bin .\Build\adc14_single_conversion_repeat_timera_source.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__,ARM_MATH_CM4
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;.\header
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: adc14_single_conversion_repeat_timera_source.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group User
    ./user/: key.c
software components: CMSIS:CORE 5.5.0
